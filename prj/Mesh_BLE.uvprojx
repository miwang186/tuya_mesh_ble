# Keil uVision project Mesh_BLE.uvprojx, settings and files
target Mesh_ble (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32L110C6PA HDSC
  pack: HDSC.HC32L110.1.0.3
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Mesh_BLE
  c flags: Optim=3 oTime=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\app;..\bsp;..\common;..\libs\driver\inc;..\libs\mcu\common;..\RTT
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group startup
    ../libs/mcu/common/: system_hc32l110.c startup_hc32l110.s
  group app
    ../app/: main.c
  group bsp
    ../bsp/: bsp.h lcd12864.c hardware_i2c.c soft_i2c.c mesh_ble.c sht30.c switch_adc.c
  group libs
    ../libs/driver/src/: interrupts_hc32l110.c adc.c adt.c bt.c ddl.c flash.c gpio.c i2c.c lpuart.c reset.c spi.c uart.c wdt.c clk.c
  group common
    ../common/: common.h hc32l110xx_config.h
  group RTT
    ../RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group readme
    ../: readme.md
software components: CMSIS:CORE 5.4.0
